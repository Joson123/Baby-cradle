# Keil uVision project emWin.uvprojx, settings and files
target emWin (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EMWIN +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\MALLOC;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\Watchdog;..\HARDWARE\USART3;..\HARDWARE\ADC;..\HARDWARE\DHT11;..\Gizwits;..\HARDWARE\USART2;..\HARDWARE\MLX90614;..\TOUCH;..\HARDWARE\IIC;..\HARDWARE\Motor;..\HARDWARE\MUSIC;..\HARDWARE\Humidifier;..\HARDWARE\Heater;..\HARDWARE\Purifier;..\HARDWARE\GPS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Watchdog/: watchdog.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/MLX90614/: mlx.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MUSIC/: music.c
    ../HARDWARE/Humidifier/: humidifier.c
    ../HARDWARE/Heater/: heater.c
    ../HARDWARE/Purifier/: purifier.c
    ../HARDWARE/GPS/: gps.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_adc.c
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.h GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_Keil.lib
  group EMWIN_Demo
    ../EMWIN/Demo/: baby.c baby-weight.c bed.c env.c environment-humidity.c environment-temperature.c milk_heater.c no-wifi.c off.c on.c smoke.c song16.c song22.c swing.c title.c title1.c tiwen.c wifi.c WindowDLG.c clean-up.c music-2.c humidifier.c safety mode.c wake-up.c babd-sscd.c baby-ssd.c Lock-off.c Lock-on.c
  group Gizwits
    ../Gizwits/: common.c dataPointTools.c gizwits_product.c gizwits_protocol.c ringbuffer.c
  group TOUCH
    ../TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c 24cxx.c
